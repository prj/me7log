# Keil uVision project fastlogging_ramhandler.uvproj, settings and files
target Target 1 (166/167)
  device: C167CR-4RM Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xE000-0xE7FF) IROM(0-0x7FFF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: fastlogging_ramhandler +hex
  group Source Group 1
    ./: fastlogging_ramhandler.a66
